# Keil uVision project CMSISrtxSemaphore.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSISrtxSemaphore
  c flags: Optim=2 v6Lang=1 v6LangP=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 6.1.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:LED 2.0.0, Device:GPIO 1.3, Device:Startup 1.0.0
